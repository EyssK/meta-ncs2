
PACKAGECONFIG_append = " gtk"
